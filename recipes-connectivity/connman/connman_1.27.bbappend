inherit systemd

SYSTEMD_AUTO_ENABLE = "disable"
